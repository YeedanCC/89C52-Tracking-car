# Keil uVision project 改过芯片的.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 改过芯片的 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Delay.c Delay.h Infraredtrack.c main.c Motordriver.c MoveState.c Timer.c Infraredtrack.h MoveState.h Timer.h Motordirver.h lcd1602.c lcd1602.h
